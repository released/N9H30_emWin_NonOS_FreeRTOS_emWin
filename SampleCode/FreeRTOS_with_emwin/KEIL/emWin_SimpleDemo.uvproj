# Keil uVision project emWin_SimpleDemo.uvproj, settings and files
target emWin_SimpleDemo_E50A2V1_16BPP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: emWin_SimpleDemo_E50A2V1_16BPP
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 wLevel=2
  c define: _PANEL_E50A2V1_16BPP_
  c include: ..\..\..\Driver\Source;..\..\..\Driver\Include;..\..\..\ThirdParty\FATFS\src;..\..\..\ThirdParty\emWin\Config;..\..\..\ThirdParty\emWin\Include;..\..\FreeRTOS_with_emwin;..\tslib;..\Application;..\..\..\ThirdParty\FreeRTOSV9.0.0\FreeRTOS\Source\portable\RVDS\ARM9_N9H30;..\..\..\ThirdParty\FreeRTOSV9.0.0\FreeRTOS\Source\include;..\..\..\ThirdParty\FreeRTOSV9.0.0\FreeRTOS\Demo\Common\include
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x80000 size 0x800000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H30.sct
  link misc: --entry 0
  group Libraries
    ../../../Driver/Source/: standalone.c sys.c sys_timer.c sys_uart.c gpio.c sdh.c lcd.c adc.c system_N9H30.c startup_N9H30.s sys_N9H30.s spi.c 2d.c jpegcodec.c
  group FatFs
    ../../../ThirdParty/FATFS/src/: ff.c
  group tslib
    ../tslib/: fbutils.c testutils.c TouchPanel.c ts_calibrate.c diskio.c SDGlue.c spilib.c
  group emWin
    ../../../ThirdParty/emWin/Config/: GUI_X.c GUIConf.c LCDConf.c
    ../../../ThirdParty/emWin/Lib/: NUemWin_ARM9_Keil.lib
  group Application
    ../Application/: FramewinDLG.c
  group src
    ../: main.c
  group FreeRTOS
    ../../../ThirdParty/FreeRTOSV9.0.0/FreeRTOS/Source/: list.c queue.c tasks.c croutine.c event_groups.c timers.c
    ../../../ThirdParty/FreeRTOSV9.0.0/FreeRTOS/Source/portable/RVDS/ARM9_N9H30/: port.c portASM.s
    ../../../ThirdParty/FreeRTOSV9.0.0/FreeRTOS/Source/portable/MemMang/: heap_4.c
target emWin_SimpleDemo_E50A2V1_16BPP_SD (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: emWin_SimpleDemo_E50A2V1_16BPP_SD
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: __USE_SD__ _PANEL_E50A2V1_16BPP_
  c include: ..\..\..\Driver\Source;..\..\..\Driver\Include;..\..\..\ThirdParty\FATFS\src;..\..\..\ThirdParty\emWin\Config;..\..\..\ThirdParty\emWin\Include;..\..\emWin_SimpleDemo;..\tslib;..\Application
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x80000 size 0x800000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H30.sct
  link misc: --entry 0
target emWin_SimpleDemo_FW070TFT_24BPP (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: emWin_SimpleDemo_FW070TFT_24BPP
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: _PANEL_FW070TFT_24BPP_
  c include: as above
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x80000 size 0x800000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H30.sct
  link misc: --entry 0
target emWin_SimpleDemo_FW070TFT_24BPP_SD (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: emWin_SimpleDemo_FW070TFT_24BPP_SD
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: __USE_SD__ _PANEL_FW070TFT_24BPP_
  c include: as above
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x80000 size 0x800000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H30.sct
  link misc: --entry 0
